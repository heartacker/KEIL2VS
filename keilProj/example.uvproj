# Keil uVision project example.uvproj, settings and files
target Target 1 (MCS-51)
  device: Core8051 Microsemi
  cpu: IRAM(0-0xFF) IROM(0-0xFFF) CLOCK(12000000)
  output: example_output +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: VS,ENDWITHThe_Comma,
  c include: .\inc
  group Source Group 1
    ./: STARTUP.A51 example.c
